# Disable experimental malloc for now because it causes memleaks with oscam
EXTRA_OECONF += "--disable-experimental-malloc"
